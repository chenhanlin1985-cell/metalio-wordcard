#include "sano_tts.hpp"
#include <filesystem>
#include <fstream>
#include <iostream>
#include <cstring>
#include <chrono>
#include <cmath>
#include <stdexcept>
#include <vector>
using namespace wordcard;
static int checks=0;
static void check(bool good,const char *why){++checks;if(!good)throw std::runtime_error(why);}
int main(int argc,char **argv) {
 try {
    check(argc==4,"Pico test arguments");
    const std::string folder=argv[1];const std::filesystem::path oracle=argv[2];
    PicoTts pico;std::string error;std::vector<int16_t> pcm;
    auto sink=[&](const int16_t *p,size_t n){pcm.insert(pcm.end(),p,p+n);return true;};
    auto go=[&](int i){pcm.clear();return pico.synthesize(folder,tts_phrases[i].text,sink,[]{return false;},error);};
    check(!pico.initialized(),"lazy initialization");
    check(!pico.synthesize(folder,"Hello",sink,[]{return true;},error) && !pico.initialized(),"pre-cancel never loads resources");
    for(int i=0;i<6;++i) {
        check(go(i),error.c_str());
        std::ifstream f(oracle/(std::to_string(i+1)+"-pico-raw.wav"),std::ios::binary);
        std::vector<char> bytes((std::istreambuf_iterator<char>(f)),{});
        check(bytes.size()==44+pcm.size()*2,"original engine reference size");
        {std::ofstream debug(std::filesystem::path(argv[3])/(std::to_string(i+1)+"-pico-wrapper.s16le"),std::ios::binary);debug.write((const char *)pcm.data(),pcm.size()*2);}
        // The unchanged upstream executable is not bit-deterministic across
        // launches either. Preserve/report this open issue; do not assert or
        // advertise PCM parity based on a loose tolerance.
        size_t different=0;double energy=0,difference=0;
        for(size_t n=0;n<pcm.size();++n){int16_t ref;std::memcpy(&ref,bytes.data()+44+2*n,2);different+=ref!=pcm[n];energy+=double(ref)*ref;double d=double(ref)-pcm[n];difference+=d*d;}
        std::cout<<"Pico phrase "<<i+1<<": original size exact; differing samples="<<different<<", SNR="<<(difference?10*std::log10(energy/difference):999)<<" dB; PCM parity NOT established\n";
        check(energy>0 && !pcm.empty(),"nonempty real reference signal");
        const auto first=pcm;check(go(i) && first.size()==pcm.size(),"warm repeat completes same utterance length");
    }
    check(!pico.synthesize(folder,"Hello",[](const int16_t *,size_t){return false;},[]{return false;},error),"sink abort");
    check(go(0),"engine recovers after sink abort");
    int polls=0;check(!pico.synthesize(folder,tts_phrases[4].text,sink,[&](){return ++polls>15;},error),"mid synthesis cancellation");
    check(go(0),"engine recovers after cancellation");
    check(!pico.synthesize(folder,std::string(1200,'a'),sink,[]{return false;},error),"bounded input");
    pico.release();check(!pico.initialized() && go(0),"explicit release and reload");
    PicoTts missing;check(!missing.prepare(folder+"-absent",error) && !missing.initialized(),"missing data fails clearly");
    auto bad=std::filesystem::path(argv[3])/("pico-corrupt-"+std::to_string(std::chrono::steady_clock::now().time_since_epoch().count()));
    std::filesystem::create_directories(bad);
    for(auto name:{"en-US_ta.bin","en-US_lh0_sg.bin"})std::filesystem::copy_file(std::filesystem::path(folder)/name,bad/name);
    {std::fstream f(bad/"en-US_ta.bin",std::ios::in|std::ios::out|std::ios::binary);char byte=0;f.read(&byte,1);byte^=1;f.seekp(0);f.write(&byte,1);}
    PicoTts corrupt;check(!corrupt.prepare(bad.string(),error) && !corrupt.initialized(),"same size corrupt resource rejected");
    HybridTts hybrid;SanoPcm result;TtsTestResult r;
    const auto ef=(std::filesystem::path(folder).parent_path()/"espeak-ng-data").string();
    for(int i=0;i<6;++i) {
        check(hybrid.benchmark(TtsTestMode::Pico,i,ef,"unused",[]{return false;},result,r),r.error);
        check(go(i) && result.count==pcm.size(),"benchmark has original utterance sample count");
        uint32_t crc=0xffffffff;
        for(size_t n=0;n<result.count;++n)for(int byte=0;byte<2;++byte){crc^=(uint16_t(result.data.get()[n])>>(8*byte))&255;for(int b=0;b<8;++b)crc=(crc>>1)^(0xedb88320u&(0u-(crc&1u)));}
        check(r.pcm_crc==~crc,"benchmark checksum describes actual generated bytes");
        check(r.actual==TtsActual::Pico && r.warm==(i>0) && r.generated && !r.memory_valid && r.compute_us>0,"truthful mode warm state and host timing");
    }
    check(!hybrid.benchmark(TtsTestMode::Pico,0,ef,"unused",[]{return true;},result,r) && r.cancelled && !result.data,"benchmark cancellation drops partial PCM");
    check(!hybrid.benchmark(TtsTestMode::Pico,0,ef,"unused",[]{return false;},result,r,1) && !result.data,"benchmark deadline drops partial PCM");
    check(hybrid.benchmark(TtsTestMode::Pico,0,ef,"unused",[]{return false;},result,r),"benchmark recovers after deadline");
    std::cout<<"PASS: "<<checks<<" Pico functional checks; six reference durations, repeat, cancellation, recovery, resources and benchmark integration; host only; PCM parity NOT established\n";
 }catch(const std::exception &e){std::cerr<<"FAIL: "<<e.what()<<'\n';return 1;}
}
